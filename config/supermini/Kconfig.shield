## config/west.yml
```yaml
manifest:
  projects:
    - name: zmk
      revision: main
  self:
    path: config
```
